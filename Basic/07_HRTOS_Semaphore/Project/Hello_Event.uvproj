# Keil uVision project Hello_Event.uvproj, settings and files
target HRTOS_Event (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: Hello_Event +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\INC
  group LIB
    ../../../../Kernel/Project/Objects/: HRTOS.LIB
  group Src
    ../Src/: HRTOS_Semaphore.c
