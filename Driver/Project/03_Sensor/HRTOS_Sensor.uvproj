# Keil uVision project HRTOS_Sensor.uvproj, settings and files
target Sensor (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: HRTOS_Sensor (library)
  c flags: SizeSpeed=1
  c include: ..\..\Inc;..\..\..\..\Kernel\Inc
  group ADC
    ../../Src/03_Sensor/ADC/: adc_get_value.c
  group DHT11
    ../../Src/03_Sensor/DHT11/: dht11_delay.c dht11_delay_10us.c dht11_init.c dht11_read.c dht11_read_byte.c
  group DS18B20
    ../../Src/03_Sensor/DS18B20/: ds18b20_init.c ds18b20_read.c ds18b20_read_bit.c ds18b20_read_byte.c ds18b20_reset.c ds18b20_start.c ds18b20_write_byte.c
  group DS1302
    ../../Src/03_Sensor/DS1302/: ds1302_init.c ds1302_read_byte.c ds1302_read_time.c ds1302_set_time.c ds1302_write_byte.c
  group 超声波
    ../../Src/03_Sensor/HC-SR04/: ultrasonic_init.c ultrasonic_measure.c ultrasonic_read.c ultrasonic_sort.c
  group 红外
    ../../Src/03_Sensor/红外传感器/: ir_init.c ir_read.c
  group 人体
    ../../Src/03_Sensor/人体感应HC-SR501/: human_init.c human_read.c
  group 雨滴
    ../../Src/03_Sensor/雨滴YL-83/: raindrop_init.c raindrop_read_ao.c raindrop_read_do.c
  group 土壤
    ../../Src/03_Sensor/土壤湿度/: soil_init.c soil_read_ao.c soil_read_do.c
  group Inc
    ../../Inc/: HRTOS_Sensor.h
