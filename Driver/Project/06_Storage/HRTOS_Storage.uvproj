# Keil uVision project HRTOS_Storage.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: HRTOS_Storage (library)
  c flags: SizeSpeed=1
  c include: ..\..\Inc;..\..\..\..\Kernel\Inc
  group Inc
    ../../Inc/: HRTOS_Storage.h
  group EEPROM
    ../../Src/06_Storage/EEPROM/EEPROM-IIC/: 24c02_read.c 24c02_write.c i2c_read_byte.c i2c_start.c i2c_stop.c i2c_write_byte.c i2c_delay.c
