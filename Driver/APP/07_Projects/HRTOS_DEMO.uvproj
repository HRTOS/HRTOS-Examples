# Keil uVision project HRTOS_DEMO.uvproj, settings and files
target DEMO (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: HRTOS_DEMO +hex
  c flags: SizeSpeed=1
  c include: ..\..\Inc;..\..\..\..\Kernel\Inc
  group LIB
    ../../../../Kernel/Project/Objects/: HRTOS.LIB
    ../../Project/03_Sensor/Objects/: HRTOS_Sensor.LIB
    ../../Project/02_Display/Objects/: HRTOS_Display.LIB
    ../../Project/05_Control/Objects/: HRTOS_Control.LIB
    ../../Project/06_Storage/Objects/: HRTOS_Storage.LIB
  group APP
    ../03_Sensor/: ultrasonic.c
  group H
    ../../Inc/: HRTOS_Basic.h HRTOS_Control.h HRTOS_Display.h hrtos_hal.h HRTOS_Sensor.h HRTOS_Storage.h
