#include "hrtos.h"
#include "hrtos_hal.h"

/*
 * =========================================================
 * DS18B20 + 4位数码管温度显示示例
 * ---------------------------------------------------------
 * 功能：
 * 1. 周期性启动 DS18B20 温度转换
 * 2. 等待温度转换完成
 * 3. 读取 DS18B20 当前温度
 * 4. 使用 4 位数码管显示温度
 *
 * 温度单位：
 * 0.01℃
 *
 * 示例：
 * 25.25℃ -> 2525
 * 18.50℃ -> 1850
 * =========================================================
 */


/*------------------------------------------------
 * DS18B20 当前温度
 *
 * 单位：0.01℃
 *
 * 例如：
 * 2525 表示 25.25℃
 * 1850 表示 18.50℃
 *------------------------------------------------*/
signed int ds18b20_temperature = 0;


/*------------------------------------------------
 * DS18B20 温度读取任务
 *------------------------------------------------*/
void task_ds18b20_read(void)
{
    while(1)
    {
        /*
         * 启动 DS18B20 温度转换
         */
        drv_ds18b20_start();

        /*
         * DS18B20 使用 12 位分辨率时，
         * 温度转换最长需要约 750ms。
         *
         * HRTOS 的 os_delay() 参数单位为 10ms，
         * 因此这里延时 75 个时间单位，即 750ms。
         */
        os_delay(75);

        /*
         * 读取温度转换结果。
         *
         * 返回值单位为 0.01℃。
         */
        ds18b20_temperature = drv_ds18b20_read();

        /*
         * 等待一段时间后进行下一次温度转换。
         */
        os_delay(25);
    }
}


/*------------------------------------------------
 * 数码管温度显示任务
 *------------------------------------------------*/
void task_seg_display(void)
{
    signed int temperature;
    unsigned int value;

    while(1)
    {
        /*
         * 读取当前温度。
         *
         * 温度数据单位为 0.01℃。
         *
         * 例如：
         * 25.25℃ -> 2525
         */
        temperature = ds18b20_temperature;

        /*
         * 当前示例仅处理非负温度。
         *
         * 将温度数值拆分为 4 位，
         * 分别显示在 4 位数码管上。
         */
        if(temperature >= 0)
        {
            value = temperature;

            /* 千位 */
            drv_seg_display(0, value / 1000);
            //os_delay(20);

            /* 百位 */
            drv_seg_display(1, value / 100 % 10);
            //os_delay(20);

            /* 十位 */
            drv_seg_display(2, value / 10 % 10);
            //os_delay(20);

            /* 个位 */
            drv_seg_display(3, value % 10);
            //os_delay(20);
        }

        /*
         * 数码管显示由底层驱动负责。
         *
         * 当前任务不主动延时，
         * 具体任务调度和显示时序由系统及驱动实现。
         */
    }
}


/**
 * @brief HRTOS 应用程序入口
 *
 * 完成 DS18B20 和数码管的初始化，
 * 并创建温度读取任务和数码管显示任务。
 */
void hrtos_main(void)
{
    /* 初始化 DS18B20 */
    drv_ds18b20_init();

    /* 初始化 4 位数码管 */
    drv_seg_init();

    /* 创建 DS18B20 温度读取任务 */
    os_task_create(
        task_ds18b20_read,
        2,
        2,
        6
    );

    /* 创建数码管显示任务 */
    os_task_create(
        task_seg_display,
        3,
        2,
        4
    );
}