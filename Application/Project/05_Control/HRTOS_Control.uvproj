# Keil uVision project HRTOS_Control.uvproj, settings and files
target Control (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: HRTOS_Control (library)
  c flags: SizeSpeed=1
  c include: ..\..\Inc;..\..\..\..\Kernel\Inc
  group Inc
    ../../Inc/: HRTOS_Control.h
  group PWM
    ../../Src/05_Control/PWM/: pwm_get_duty.c pwm_init.c pwm_set_duty.c pwm_start.c pwm_stop.c
  group Relay
    ../../Src/05_Control/Relay/: relay_get.c relay_init.c relay_off.c relay_on.c relay_set.c
