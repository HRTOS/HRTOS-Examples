# Keil uVision project HRTOS_HAL.uvproj, settings and files
target HAL (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: HRTOS_HAL (library)
  c flags: Optimize=8 SizeSpeed=1
  group LIB
    ../01_Basic/Objects/: HRTOS_Basic.LIB
    ../02_Display/Objects/: HRTOS_Display.LIB
    ../03_Sensor/Objects/: HRTOS_Sensor.LIB
    ../04_Communication/Objects/: HRTOS_Communication.LIB
    ../05_Control/Objects/: HRTOS_Control.LIB
    ../06_Storage/Objects/: HRTOS_Storage.LIB
