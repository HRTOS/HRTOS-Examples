# Keil uVision project HRTOS_Display.uvproj, settings and files
target Display (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: HRTOS_Display (library)
  c flags: SizeSpeed=1
  c include: ..\..\Inc;..\..\..\..\Kernel\Inc
  group Segment
    ../../Src/02_Display/Segment/: seg_display.c seg_init.c
  group LCD1602
    ../../Src/02_Display/LCD1602/: lcd1602_init.c lcd1602_set_cursor.c lcd1602_write_cmd.c lcd1602_write_data.c lcd1602_write_string.c lcd1602_delay_ms.c lcd1602_delay_us.c
  group OLED
    ../../Src/02_Display/OLED/: oled_clear.c oled_draw_bmp.c oled_fill.c oled_iic_start.c oled_iic_stop.c oled_iic_wait_ack.c oled_iic_write_byte.c oled_init.c oled_off.c oled_on.c oled_pow.c oled_set_pos.c oled_show_char.c oled_show_chinese.c oled_show_num.c oled_show_string.c oled_write_command.c oled_write_data.c
  group Inc
    ../../Inc/: HRTOS_Display.h
