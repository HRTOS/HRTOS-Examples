# Keil uVision project HRTOS_Basic.uvproj, settings and files
target Basic (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: HRTOS_Basic (library)
  c flags: SizeSpeed=1
  c include: ..\..\Inc;..\..\..\..\Kernel\Inc
  group Inc
    ../../Inc/: HRTOS_Basic.h HRTOS_Comm.h HRTOS_Control.h HRTOS_Display.h hrtos_hal.h HRTOS_Sensor.h HRTOS_Storage.h
  group Buzzer
    ../../Src/01_Basic/Buzzer/: beep_init.c beep_off.c beep_on.c beep_toggle.c
  group INT0
    ../../Src/01_Basic/INT0/: int0_init.c
  group INT1
    ../../Src/01_Basic/INT1/: int1_init.c
  group KEY
    ../../Src/01_Basic/KEY/: key_init.c key_scan.c
  group KEY_Matrix
    ../../Src/01_Basic/KEY_Matrix/: matrixkey_init.c matrixkey_scan.c
  group LED
    ../../Src/01_Basic/LED/: led_init.c led_off.c led_on.c led_toggle.c led_write.c
  group Timer1
    ../../Src/01_Basic/Timer1/: timer1_init.c
